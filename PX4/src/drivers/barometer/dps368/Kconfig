## PX4/src/drivers/barometer/dps368/Kconfig
```kconfig
menuconfig DRIVERS_BAROMETER_DPS368
	bool "dps368"
	default n
	---help---
		Enable support for dps368
```
